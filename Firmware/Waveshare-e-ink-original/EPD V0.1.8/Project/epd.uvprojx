# Keil uVision project epd.uvprojx, settings and files
target mdk (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: epd +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Lib\src;..\Lib\inc;..\User;..\Lib\Start;..\Lib;..\Lib\minigui;..\Lib\FatFS;..\Lib\minigui\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group start
    ../Lib/Start/: startup_stm32f10x_hd.s
  group lib
    ../Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Lib/: system_stm32f10x.c
  group user
    ../User/: main.c stm32f10x_it.c sdcard.c arm_cortex_m.c epd.lib
    ../Lib/minigui/: minigui.lib
  group minigui_font
    ../Lib/minigui/font/: flash_font.c F64.c F32.c F48.c
  group fatfs
    ../Lib/FatFS/: ff.c diskio.c
